options:
  parameters:
    generate_options: qt_gui
    id: testCalibrateSignals
    output_language: python
    title: Test Calibration of Signals
  states: {}

blocks:
- name: delay_1
  id: variable_qtgui_range
  parameters:
    label: Delay 1
    start: '1'
    step: '1'
    stop: '1000'
    value: '50'
  states: {}
- name: delay_2
  id: variable_qtgui_range
  parameters:
    label: Delay 2
    start: '1'
    step: '1'
    stop: '1000'
    value: '50'
  states: {}
- name: delay_3
  id: variable_qtgui_range
  parameters:
    label: Delay 3
    start: '1'
    step: '1'
    stop: '1000'
    value: '50'
  states: {state: disabled}
- name: phase_1
  id: variable_qtgui_range
  parameters:
    label: Phase 1
    start: '-3.14'
    step: '0.01'
    stop: '3.14'
    value: '0'
  states: {}
- name: phase_2
  id: variable_qtgui_range
  parameters:
    label: Phase 2
    start: '-3.14'
    step: '0.01'
    stop: '3.14'
    value: '0'
  states: {}
- name: phase_3
  id: variable_qtgui_range
  parameters:
    label: Phase 3
    start: '-3.14'
    step: '0.01'
    stop: '3.14'
    value: '0'
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: synchronize
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Synchronize
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: Correlation_0
  id: Correlation
  parameters:
    vector_length: '32768'
  states: {}
- name: Correlation_0_0
  id: Correlation
  parameters:
    vector_length: '32768'
  states: {state: disabled}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: int(-vector_length/2)
    type: short
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: int(-vector_length/2)
    type: short
  states: {state: disabled}
- name: blocks_argmax_xx_0_0_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: vector_length
  states: {}
- name: blocks_argmax_xx_0_0_0_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: vector_length
  states: {}
- name: blocks_argmax_xx_0_0_0_0_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: vector_length
  states: {state: disabled}
- name: blocks_argmax_xx_0_0_0_1
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: vector_length
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_arg_0_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: int(vector_length)
  states: {}
- name: blocks_complex_to_mag_0_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: int(vector_length)
  states: {}
- name: blocks_complex_to_mag_0_0_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: int(vector_length)
  states: {}
- name: blocks_complex_to_mag_0_0_0_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: int(vector_length)
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0_0_1
  id: blocks_complex_to_mag
  parameters:
    vlen: int(vector_length)
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0_1
  id: blocks_complex_to_mag
  parameters:
    vlen: int(vector_length)
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay_1
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: delay_2
    type: complex
  states: {}
- name: blocks_delay_0_0_0
  id: blocks_delay
  parameters:
    delay: delay_2
    type: complex
  states: {state: disabled}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: int(vector_length/2)
    type: complex
  states: {}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: int(vector_length/2)
    type: complex
  states: {}
- name: blocks_delay_1_0_0
  id: blocks_delay
  parameters:
    delay: int(vector_length/2)
    type: complex
  states: {state: disabled}
- name: blocks_delay_1_1
  id: blocks_delay
  parameters:
    delay: int(vector_length/2)
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_null_sink_0_0_0_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_null_sink_0_0_0_1
  id: blocks_null_sink
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_phase_shift_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: phase_1
  states: {}
- name: blocks_phase_shift_0_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: phase_2
  states: {}
- name: blocks_phase_shift_0_0_0
  id: blocks_phase_shift
  parameters:
    is_radians: 'True'
    shift: phase_2
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(vector_length)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(vector_length)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(vector_length)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_1_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(vector_length)
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1_1_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: int(vector_length)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0_1_1_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(vector_length)
    type: complex
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_length
    type: complex
  states: {state: disabled}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):

          def __init__(self, vectorLength = 32768):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Get one value from vector',
                  in_sig=[(np.complex64,vectorLength), np.short],
                  out_sig=[np.complex64]
              )
              self.vectorLength = vectorLength

          def work(self, input_items, output_items):
              #for portIndex in range(len(input_items)):
              #    for vectorIndex in range(len(input_items[portIndex])):
              #        print("input_items[",portIndex,"][",vectorIndex,"] =", input_items[portIndex][vectorIndex])
              maximumCorrelationIndex = input_items[1][len(input_items[1])-1]
              wantedValue = input_items[0][len(input_items[0])-1][maximumCorrelationIndex]
              output_items[0][0] = wantedValue
              return 1
    vectorLength: int(vector_length)
  states: {}
- name: epy_block_1_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):

          def __init__(self, vectorLength = 32768):  # only default arguments here
              gr.sync_block.__init__(
                  self,
                  name='Get one value from vector',
                  in_sig=[(np.complex64,vectorLength), np.short],
                  out_sig=[np.complex64]
              )
              self.vectorLength = vectorLength

          def work(self, input_items, output_items):
              #for portIndex in range(len(input_items)):
              #    for vectorIndex in range(len(input_items[portIndex])):
              #        print("input_items[",portIndex,"][",vectorIndex,"] =", input_items[portIndex][vectorIndex])
              maximumCorrelationIndex = input_items[1][len(input_items[1])-1]
              wantedValue = input_items[0][len(input_items[0])-1][maximumCorrelationIndex]
              output_items[0][0] = wantedValue
              return 1
    vectorLength: int(vector_length)
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"Phase Difference 1 & 2"'
    type: float
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"Phase Difference 1 & 3"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"Delay value 1 & 3"'
    type: short
  states: {}
- name: qtgui_number_sink_0_0_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"Delay value  1 & 3"'
    type: short
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.2'
    name: '"Delay  1 & 2"'
    vlen: int(vector_length)
    x_start: int(-vector_length/2)
    x_step: '1'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.2'
    name: '"Delay  1 & 3"'
    vlen: int(vector_length)
    x_start: int(-vector_length/2)
    x_step: '1'
  states: {state: disabled}
- name: synchronize_signals_module_synchronize_signals_0
  id: synchronize_signals_module_synchronize_signals
  parameters:
    fft_size: vector_length
    num_ports: '2'
    synchronize: synchronize
  states: {}

connections:
- [Correlation_0, '0', blocks_delay_1, '0']
- [Correlation_0, '0', blocks_delay_1_0, '0']
- [Correlation_0, '0', blocks_stream_to_vector_0_1_1, '0']
- [Correlation_0_0, '0', blocks_delay_1_0_0, '0']
- [Correlation_0_0, '0', blocks_delay_1_1, '0']
- [Correlation_0_0, '0', blocks_stream_to_vector_0_1_1_1, '0']
- [analog_fastnoise_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_add_const_vxx_0_0_0, '0', qtgui_number_sink_0_0_0, '0']
- [blocks_add_const_vxx_0_0_0_0, '0', qtgui_number_sink_0_0_0_0, '0']
- [blocks_argmax_xx_0_0_0, '0', epy_block_1, '1']
- [blocks_argmax_xx_0_0_0, '1', blocks_null_sink_0_0_0, '0']
- [blocks_argmax_xx_0_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [blocks_argmax_xx_0_0_0_0, '1', blocks_null_sink_0_0_0_0, '0']
- [blocks_argmax_xx_0_0_0_0_0, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [blocks_argmax_xx_0_0_0_0_0, '1', blocks_null_sink_0_0_0_0_0, '0']
- [blocks_argmax_xx_0_0_0_1, '0', epy_block_1_0, '1']
- [blocks_argmax_xx_0_0_0_1, '1', blocks_null_sink_0_0_0_1, '0']
- [blocks_complex_to_arg_0, '0', qtgui_number_sink_0, '0']
- [blocks_complex_to_arg_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_complex_to_mag_0_0_0, '0', blocks_argmax_xx_0_0_0, '0']
- [blocks_complex_to_mag_0_0_0_0, '0', blocks_argmax_xx_0_0_0_0, '0']
- [blocks_complex_to_mag_0_0_0_0_0, '0', blocks_argmax_xx_0_0_0_0_0, '0']
- [blocks_complex_to_mag_0_0_0_1, '0', blocks_argmax_xx_0_0_0_1, '0']
- [blocks_complex_to_mag_0_0_1, '0', qtgui_vector_sink_f_0_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_delay_0_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_0_0_0, '0', blocks_stream_to_vector_0_0_0, '0']
- [blocks_delay_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_delay_1_0, '0', blocks_stream_to_vector_0_1_1_0, '0']
- [blocks_delay_1_0_0, '0', blocks_stream_to_vector_0_1_1_0_0, '0']
- [blocks_delay_1_1, '0', blocks_stream_to_vector_0_1_0, '0']
- [blocks_phase_shift_0, '0', blocks_delay_0, '0']
- [blocks_phase_shift_0_0, '0', blocks_delay_0_0, '0']
- [blocks_phase_shift_0_0_0, '0', blocks_delay_0_0_0, '0']
- [blocks_stream_to_vector_0, '0', synchronize_signals_module_synchronize_signals_0, '0']
- [blocks_stream_to_vector_0_0, '0', synchronize_signals_module_synchronize_signals_0, '1']
- [blocks_stream_to_vector_0_1, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_stream_to_vector_0_1_0, '0', blocks_complex_to_mag_0_0_1, '0']
- [blocks_stream_to_vector_0_1_1, '0', blocks_complex_to_mag_0_0_0, '0']
- [blocks_stream_to_vector_0_1_1, '0', epy_block_1, '0']
- [blocks_stream_to_vector_0_1_1_0, '0', blocks_complex_to_mag_0_0_0_0, '0']
- [blocks_stream_to_vector_0_1_1_0_0, '0', blocks_complex_to_mag_0_0_0_0_0, '0']
- [blocks_stream_to_vector_0_1_1_1, '0', blocks_complex_to_mag_0_0_0_1, '0']
- [blocks_stream_to_vector_0_1_1_1, '0', epy_block_1_0, '0']
- [blocks_throttle2_0, '0', blocks_phase_shift_0, '0']
- [blocks_throttle2_0, '0', blocks_phase_shift_0_0, '0']
- [blocks_throttle2_0, '0', blocks_phase_shift_0_0_0, '0']
- [blocks_vector_to_stream_0, '0', Correlation_0, '0']
- [blocks_vector_to_stream_0, '0', Correlation_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', Correlation_0, '1']
- [blocks_vector_to_stream_0_0_0, '0', Correlation_0_0, '1']
- [epy_block_1, '0', blocks_complex_to_arg_0, '0']
- [epy_block_1_0, '0', blocks_complex_to_arg_0_0, '0']
- [synchronize_signals_module_synchronize_signals_0, '0', blocks_vector_to_stream_0, '0']
- [synchronize_signals_module_synchronize_signals_0, '1', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
