options:
  parameters:
    generate_options: qt_gui
    id: testCalibrateSignals
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: delay
  id: variable_qtgui_range
  parameters:
    start: '-1000'
    step: '1'
    stop: '1000'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: synchronize
  id: variable_qtgui_check_box
  parameters:
    'false': 'False'
    label: Synchronize
    'true': 'True'
    type: bool
    value: 'False'
  states: {}
- name: vector_length
  id: variable
  parameters:
    value: '32768'
  states: {}
- name: Correlation_0
  id: Correlation
  parameters:
    vector_length: '32768'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: '1'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: int(-vector_length/2)
    type: short
  states: {}
- name: blocks_argmax_xx_0_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: vector_length
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: int(vector_length)
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: delay
    type: complex
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: int(vector_length/2)
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: int(vector_length)
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: vector_length
    type: complex
  states: {}
- name: qtgui_number_sink_0_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    name: '"Delay value"'
    type: short
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.2'
    name: '"Delay"'
    vlen: int(vector_length)
    x_start: int(-vector_length/2)
    x_step: '1'
  states: {}
- name: synchronize_signals_module_synchronize_signals_0
  id: synchronize_signals_module_synchronize_signals
  parameters:
    fft_size: vector_length
    synchronize: synchronize
  states: {}

connections:
- [Correlation_0, '0', blocks_delay_1, '0']
- [analog_fastnoise_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_add_const_vxx_0_0, '0', qtgui_number_sink_0_0, '0']
- [blocks_argmax_xx_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_argmax_xx_0_0, '1', blocks_null_sink_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', blocks_argmax_xx_0_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_delay_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_delay_1, '0', blocks_stream_to_vector_0_1, '0']
- [blocks_stream_to_vector_0, '0', synchronize_signals_module_synchronize_signals_0, '0']
- [blocks_stream_to_vector_0_0, '0', synchronize_signals_module_synchronize_signals_0, '1']
- [blocks_stream_to_vector_0_1, '0', blocks_complex_to_mag_0_0, '0']
- [blocks_throttle2_0, '0', blocks_delay_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', Correlation_0, '0']
- [blocks_vector_to_stream_0_0, '0', Correlation_0, '1']
- [synchronize_signals_module_synchronize_signals_0, '0', blocks_vector_to_stream_0, '0']
- [synchronize_signals_module_synchronize_signals_0, '1', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
